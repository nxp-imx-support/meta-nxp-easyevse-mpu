FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " \
    file://0001-EasyEVSE-Add-EasyEVSE-defconfig.patch \
"